<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/lino/Desktop/tirocinio/file/out.txt</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/lino/Desktop/tirocinio/file/in.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>rsaRx_rsaRx_py_fb</key>
<param><key>id</key><value>rsaRx_rsaRx_py_fb_1</value></param>
<param><key>d</key><value>147</value></param>
<param><key>n</key><value>943</value></param>
</block>
<block>
<key>rsa_rsaTX_py_bf</key>
<param><key>id</key><value>rsa_rsaTX_py_bf_0</value></param>
<param><key>e</key><value>3</value></param>
<param><key>n</key><value>943</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>rsa_rsaTX_py_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rsaRx_rsaRx_py_fb_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rsa_rsaTX_py_bf_0</source_block_id><sink_block_id>rsaRx_rsaRx_py_fb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
